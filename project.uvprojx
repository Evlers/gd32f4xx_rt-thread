# Keil uVision project project.uvprojx, settings and files
target rt-thread (ARM-ADS)
  device: GD32F470ZG GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x070000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, USE_STDPERIPH_DRIVER, GD32F470, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__
  c include: packages\netutils\ntp;packages\netutils\tftp;rt-thread\components\finsh;rt-thread\components\libc\posix\io\stdio;rt-thread\components\drivers\spi;packages\webclient\inc;rt-thread\components\net\sal\include;rt-thread\libcpu\arm\common;rt-thread\components\dfs\filesystems\elmfat;rt-thread\libcpu\arm\cortex-m4;rt-thread\components\drivers\wlan;packages\mbedtls\mbedtls\library;libraries\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include;packages\optparse;rt-thread\include;libraries\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include;rt-thread\components\libc\compilers\common\extension\fcntl\octal;rt-thread\components\net\netdev\include;packages\rw007\inc;rt-thread\components\drivers\include;board;packages\mbedtls\mbedtls\include;rt-thread\components\net\sal\include\dfs_net;rt-thread\components\drivers\include;libraries\gd32_drivers;applications;rt-thread\components\drivers\include;rt-thread\components\drivers\include;rt-thread\components\dfs\include;.;rt-thread\components\net\sal\include\socket\sys_socket;rt-thread\components\dfs\filesystems\devfs;rt-thread\components\utilities\resource;packages\pahomqtt\MQTTPacket\src;rt-thread\components\libc\posix\io\poll;packages\pahomqtt\MQTTClient-RT;rt-thread\components\net\lwip\lwip-2.0.3\src\include;rt-thread\components\net\sal\include\socket;rt-thread\components\drivers\include;rt-thread\components\net\lwip\port;libraries\GD32F4xx_Firmware_Library\CMSIS;rt-thread\components\net\sal\impl;packages\rw007;rt-thread\components\drivers\include;rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4;packages\mbedtls\ports\inc;board\ports;rt-thread\components\libc\compilers\common\extension;rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif;rt-thread\components\libc\posix\ipc;rt-thread\components\libc\compilers\common\include;rt-thread\components\fal\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x70000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applications
    applications/: main.c
  group Compiler
    rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    rt-thread/libcpu/arm/common/: div0.c showmem.c
    rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    rt-thread/components/drivers/misc/: pin.c
    rt-thread/components/drivers/mtd/: mtd_nor.c
    rt-thread/components/drivers/rtc/: rtc.c
    rt-thread/components/drivers/serial/: serial.c
    rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    rt-thread/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group Drivers
    board/: board.c
    board/ports/: rw007_port.c
    libraries/GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f4xx.s
    libraries/gd32_drivers/: drv_flash.c drv_gpio.c drv_rtc.c drv_spi.c drv_usart.c
  group Fal
    rt-thread/components/fal/src/: fal_partition.c fal_rtt.c fal.c fal_flash.c
  group Filesystem
    rt-thread/components/dfs/filesystems/devfs/: devfs.c
    rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    libraries/GD32F4xx_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_syscfg.c gd32f4xx_exti.c gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_fmc.c gd32f4xx_pmu.c gd32f4xx_misc.c gd32f4xx_usart.c gd32f4xx_spi.c gd32f4xx_rtc.c
    libraries/GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group lwIP
    rt-thread/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group mbedtls
    packages/mbedtls/ports/src/: timing_alt.c md5_alt.c tls_certificate.c tls_client.c tls_net.c arc4_alt.c sha256_alt.c rsa_alt.c sha1_alt.c sha512_alt.c tls_hardware.c aes_alt.c des_alt.c
    packages/mbedtls/mbedtls/library/: chacha20.c threading.c x509_crl.c md2.c pk_wrap.c x509_create.c ecjpake.c ssl_srv.c md5.c pkwrite.c mps_trace.c hmac_drbg.c psa_crypto_aead.c bignum.c mps_reader.c psa_crypto_hash.c sha256.c ecp.c pkcs12.c psa_crypto_storage.c ssl_ciphersuites.c xtea.c aes.c psa_crypto_cipher.c cipher.c sha512.c version.c md4.c psa_crypto_slot_management.c asn1parse.c camellia.c aria.c poly1305.c cipher_wrap.c entropy.c pkparse.c certs.c gcm.c x509write_csr.c x509_crt.c asn1write.c oid.c sha1.c aesni.c psa_crypto_driver_wrappers.c havege.c pkcs5.c entropy_poll.c ripemd160.c des.c x509.c psa_crypto_mac.c arc4.c rsa.c ssl_cache.c base64.c pkcs11.c psa_its_file.c version_features.c rsa_internal.c ssl_tls13_keys.c debug.c nist_kw.c platform_util.c constant_time.c ecdsa.c ssl_cli.c x509write_crt.c padlock.c blowfish.c ecp_curves.c timing.c ccm.c chachapoly.c ssl_cookie.c ctr_drbg.c pem.c psa_crypto.c hkdf.c x509_csr.c md.c platform.c psa_crypto_ecp.c dhm.c error.c memory_buffer_alloc.c ssl_tls.c psa_crypto_se.c cmac.c ssl_msg.c psa_crypto_rsa.c ecdh.c pk.c psa_crypto_client.c ssl_ticket.c
  group NetUtils
    packages/netutils/iperf/: iperf.c
    packages/netutils/netio/: netio.c
    packages/netutils/ntp/: ntp.c
    packages/netutils/tcpdump/: tcpdump.c
    packages/netutils/telnet/: telnet.c
    packages/netutils/tftp/: tftp_client.c tftp_port.c tftp_server.c tftp_xfer.c
  group optparse
    packages/optparse/: optparse.c
  group paho-mqtt
    packages/pahomqtt/MQTTPacket/src/: MQTTUnsubscribeServer.c MQTTSubscribeClient.c MQTTConnectServer.c MQTTSubscribeServer.c MQTTFormat.c MQTTUnsubscribeClient.c MQTTDeserializePublish.c MQTTSerializePublish.c MQTTConnectClient.c MQTTPacket.c
    packages/pahomqtt/MQTTClient-RT/: paho_mqtt_pipe.c
    packages/pahomqtt/samples/: mqtt_sample.c
    packages/pahomqtt/tests/: mqtt_test.c
  group POSIX
    rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group rw007
    packages/rw007/src/: spi_wifi_rw007.c
  group SAL
    rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    rt-thread/components/net/sal/dfs_net/: dfs_net.c
    rt-thread/components/net/sal/impl/: af_inet_lwip.c
    rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    rt-thread/components/net/sal/src/: sal_socket.c
  group Utilities
    rt-thread/components/utilities/resource/: resource_id.c
  group WebClient
    packages/webclient/src/: webclient_file.c webclient.c
software components: CMSIS:CORE 5.5.0
