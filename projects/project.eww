<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\C:\Users\14252\Desktop\demo\rt-thread\gd32f470_rt-thread-v5.0.0/projects\project.ewp</path>
  </project>
  <batchBuild/>
</workspace>


