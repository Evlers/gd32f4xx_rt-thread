# Keil uVision project project.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F470VI GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x0B0000) IRAM2(0x10000000,0x010000) IROM(0x08000000,0x0200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: __STDC_LIMIT_MACROS, RT_USING_ARMLIBC, USE_STDPERIPH_DRIVER, GD32F470, RT_USING_LIBC, __CLK_TCK=RT_TICK_PER_SECOND, __RTTHREAD__
  c include: ..\packages\netutils\ntp;..\packages\netutils\tftp;..\libraries\wifi-host-driver\wifi-host-driver\WiFi_Host_Driver\src\include;..\rt-thread\components\finsh;..\libraries\wifi-host-driver\wifi-host-driver\WiFi_Host_Driver\resources\nvram\COMPONENT_43438\COMPONENT_AW-CU427-P;..\rt-thread\components\libc\posix\io\stdio;..\rt-thread\components\drivers\spi;..\packages\webclient\inc;..\rt-thread\components\drivers\wlan;..\rt-thread\libcpu\arm\common;..\rt-thread\components\dfs\filesystems\elmfat;..\rt-thread\components\net\lwip-dhcpd;..\rt-thread\libcpu\arm\cortex-m4;..\rt-thread\components\drivers\include;..\packages\mbedtls\mbedtls\library;..\libraries\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include;..\packages\optparse;..\rt-thread\include;..\libraries\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include;..\rt-thread\components\libc\compilers\common\extension\fcntl\octal;..\rt-thread\components\net\netdev\include;..\libraries\drivers;..\rt-thread\components\drivers\include;..\libraries\wifi-host-driver\wifi-host-driver\WiFi_Host_Driver\resources\resource_imp;..\board;..\libraries\wifi-host-driver\porting\inc\bsp;..\packages\mbedtls\mbedtls\include;..\rt-thread\components\net\sal\include\dfs_net;..\rt-thread\components\drivers\include;..\applications;..\libraries\wifi-host-driver\wifi-host-driver\WiFi_Host_Driver\resources\firmware\COMPONENT_43438;..\rt-thread\components\drivers\include;..\libraries\wifi-host-driver\wifi-host-driver\WiFi_Host_Driver\src\bus_protocols;..\rt-thread\components\drivers\include;..\rt-thread\components\dfs\include;..;..\rt-thread\components\net\sal\include\socket\sys_socket;..\rt-thread\components\dfs\filesystems\devfs;..\rt-thread\components\utilities\resource;..\packages\pahomqtt\MQTTPacket\src;..\rt-thread\components\libc\posix\io\poll;..\packages\pahomqtt\MQTTClient-RT;..\libraries\wifi-host-driver\porting\inc\rtos;..\rt-thread\components\net\lwip\lwip-2.0.3\src\include;..\rt-thread\components\net\sal\include;..\rt-thread\components\net\sal\include\socket;..\rt-thread\components\drivers\include;..\libraries\wifi-host-driver\wifi-host-driver;..\rt-thread\components\net\lwip\port;..\libraries\GD32F4xx_Firmware_Library\CMSIS;..\libraries\wifi-host-driver\porting\inc\hal;..\rt-thread\components\net\sal\impl;..\rt-thread\components\drivers\include;..\rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4;..\packages\mbedtls\ports\inc;..\libraries\wifi-host-driver\wifi-host-driver\WiFi_Host_Driver\inc;..\packages\EasyFlash\inc;..\board\ports;..\rt-thread\components\libc\compilers\common\extension;..\libraries\wifi-host-driver\wifi-host-driver\WiFi_Host_Driver\resources\clm\COMPONENT_43438;..\rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif;..\rt-thread\components\libc\posix\ipc;..\rt-thread\components\libc\compilers\common\include;..\libraries\wifi-host-driver\wifi-host-driver\WiFi_Host_Driver\src;..\rt-thread\components\fal\inc
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0xb0000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applications
    ../applications/: main.c
  group Compiler
    ../rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
  group CPU
    ../rt-thread/libcpu/arm/common/: div0.c showmem.c
    ../rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group DeviceDrivers
    ../rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../rt-thread/components/drivers/misc/: pin.c
    ../rt-thread/components/drivers/mtd/: mtd_nor.c
    ../rt-thread/components/drivers/rtc/: rtc.c
    ../rt-thread/components/drivers/sdio/: block_dev.c gpt.c mmc.c mmcsd_core.c sd.c sdio.c
    ../rt-thread/components/drivers/serial/: serial.c
    ../rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    ../rt-thread/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group Drivers
    ../board/: board.c
    ../board/ports/: ef_fal_port.c fal_port.c rw007_port.c wifi_config.c
    ../libraries/GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/ARM/: startup_gd32f4xx.s
    ../libraries/drivers/: delay.c drv_flash.c drv_gpio.c drv_rtc.c drv_sdio.c drv_sdio_crc.c drv_spi.c drv_usart.c
  group EasyFlash
    ../packages/EasyFlash/src/: ef_cmd.c ef_iap.c ef_utils.c ef_env_legacy_wl.c ef_log.c easyflash.c ef_env.c ef_env_legacy.c
  group Fal
    ../rt-thread/components/fal/src/: fal_rtt.c fal.c fal_partition.c fal_flash.c
  group Filesystem
    ../rt-thread/components/dfs/filesystems/devfs/: devfs.c
    ../rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../libraries/GD32F4xx_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_syscfg.c gd32f4xx_dma.c gd32f4xx_exti.c gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_fmc.c gd32f4xx_pmu.c gd32f4xx_misc.c gd32f4xx_usart.c gd32f4xx_spi.c gd32f4xx_rtc.c gd32f4xx_sdio.c
    ../libraries/GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group lwIP
    ../rt-thread/components/net/lwip-dhcpd/: dhcp_server_raw.c
    ../rt-thread/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../rt-thread/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group mbedtls
    ../packages/mbedtls/mbedtls/library/: ssl_cache.c x509.c cipher.c poly1305.c chachapoly.c aria.c md4.c x509_create.c memory_buffer_alloc.c mps_trace.c sha512.c timing.c dhm.c asn1parse.c entropy.c psa_crypto_driver_wrappers.c rsa.c asn1write.c ctr_drbg.c pkwrite.c x509_csr.c version_features.c debug.c ecp_curves.c pkparse.c ssl_cli.c ecdh.c ssl_tls.c bignum.c psa_crypto_mac.c psa_crypto_aead.c x509_crl.c x509write_csr.c cipher_wrap.c platform_util.c ssl_ciphersuites.c arc4.c ssl_tls13_keys.c constant_time.c ecjpake.c x509write_crt.c cmac.c hkdf.c xtea.c des.c ecp.c error.c psa_crypto_rsa.c pk_wrap.c ecdsa.c psa_crypto_ecp.c aesni.c camellia.c x509_crt.c rsa_internal.c nist_kw.c psa_crypto_client.c ccm.c certs.c pkcs11.c sha1.c psa_crypto_se.c aes.c ssl_srv.c oid.c mps_reader.c chacha20.c ripemd160.c version.c ssl_ticket.c blowfish.c pem.c padlock.c psa_crypto.c md2.c md.c psa_crypto_slot_management.c base64.c gcm.c pkcs5.c platform.c ssl_msg.c pk.c sha256.c psa_crypto_hash.c havege.c ssl_cookie.c md5.c psa_its_file.c hmac_drbg.c psa_crypto_storage.c threading.c pkcs12.c entropy_poll.c psa_crypto_cipher.c
    ../packages/mbedtls/ports/src/: arc4_alt.c rsa_alt.c sha1_alt.c tls_client.c tls_net.c tls_certificate.c sha512_alt.c sha256_alt.c des_alt.c tls_hardware.c md5_alt.c timing_alt.c aes_alt.c
  group NetUtils
    ../packages/netutils/iperf/: iperf.c
    ../packages/netutils/netio/: netio.c
    ../packages/netutils/ntp/: ntp.c
    ../packages/netutils/tcpdump/: tcpdump.c
    ../packages/netutils/telnet/: telnet.c
    ../packages/netutils/tftp/: tftp_client.c tftp_port.c tftp_server.c tftp_xfer.c
  group optparse
    ../packages/optparse/: optparse.c
  group paho-mqtt
    ../packages/pahomqtt/MQTTPacket/src/: MQTTConnectClient.c MQTTSerializePublish.c MQTTSubscribeServer.c MQTTSubscribeClient.c MQTTConnectServer.c MQTTUnsubscribeClient.c MQTTUnsubscribeServer.c MQTTPacket.c MQTTFormat.c MQTTDeserializePublish.c
    ../packages/pahomqtt/MQTTClient-RT/: paho_mqtt_pipe.c
    ../packages/pahomqtt/tests/: mqtt_test.c
    ../packages/pahomqtt/samples/: mqtt_sample.c
  group POSIX
    ../rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group SAL
    ../rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../rt-thread/components/net/sal/dfs_net/: dfs_net.c
    ../rt-thread/components/net/sal/impl/: af_inet_lwip.c
    ../rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    ../rt-thread/components/net/sal/src/: sal_socket.c
  group Utilities
    ../rt-thread/components/utilities/resource/: resource_id.c
  group WebClient
    ../packages/webclient/src/: webclient.c webclient_file.c
  group whd
    ../libraries/wifi-host-driver/wifi-host-driver/WiFi_Host_Driver/src/: whd_wifi.c whd_proto.c whd_chip.c whd_ring.c whd_wifi_api.c whd_cdc_bdc.c whd_flowring.c whd_sdpcm.c whd_clm.c whd_wifi_p2p.c whd_management.c whd_events.c whd_debug.c whd_commonring.c whd_resource_if.c whd_buffer_api.c whd_thread.c whd_logging.c whd_chip_constants.c whd_ap.c whd_msgbuf_txrx.c whd_utils.c whd_network_if.c
    ../libraries/wifi-host-driver/porting/src/wlan/: cyw_wlan.c
    ../libraries/wifi-host-driver/porting/src/hal/: cyhal_gpio.c cyhal_sdio.c
    ../libraries/wifi-host-driver/porting/src/bsp/: cy_network_buffer.c cybsp.c
    ../libraries/wifi-host-driver/wifi-host-driver/WiFi_Host_Driver/src/bus_protocols/: whd_bus_common.c whd_bus_sdio_protocol.c whd_bus.c
    ../libraries/wifi-host-driver/wifi-host-driver/WiFi_Host_Driver/resources/resource_imp/: whd_resources.c
    ../libraries/wifi-host-driver/wifi-host-driver/WiFi_Host_Driver/resources/firmware/COMPONENT_43438/: 43438A1_bin.c
    ../libraries/wifi-host-driver/wifi-host-driver/WiFi_Host_Driver/resources/clm/COMPONENT_43438/: 43438A1_clm_blob.c
    ../libraries/wifi-host-driver/porting/src/rtos/: whd_rtos.c
software components: CMSIS:CORE 5.4.0
