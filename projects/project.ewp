# IAR project project.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F450xK GD GD32F450xK
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F4XX; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT; GD32F470; __RTTHREAD__; USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\packages\netutils\ntp; ..\rt-thread\components\drivers\include; ..\rt-thread\components\libc\compilers\common\extension; ..\rt-thread\components\libc\posix\ipc; ..\rt-thread\components\fal\inc; ..\packages\webclient\inc; ..\rt-thread\components\net\sal\impl; ..\rt-thread\components\dfs\include; ..\packages\optparse; ..\rt-thread\libcpu\arm\common; ..\rt-thread\components\net\lwip\port; ..\rt-thread\components\dfs\filesystems\devfs; ..\rt-thread\libcpu\arm\cortex-m4; ..; ..\board; ..\packages\pahomqtt\MQTTClient-RT; ..\packages\pahomqtt\MQTTPacket\src; ..\packages\mbedtls\mbedtls\include; ..\rt-thread\components\net\sal\include\socket; ..\packages\rw007; ..\rt-thread\include; ..\rt-thread\components\libc\compilers\common\include; ..\packages\netutils\tftp; ..\applications; ..\rt-thread\components\net\sal\include; ..\rt-thread\components\net\lwip\lwip-2.0.3\src\include\netif; ..\packages\mbedtls\mbedtls\library; ..\rt-thread\components\libc\compilers\common\extension\fcntl\octal; ..\packages\mbedtls\ports\inc; ..\rt-thread\components\utilities\resource; ..\rt-thread\components\libc\posix\io\poll; ..\board\ports; ..\libraries\GD32F4xx_Firmware_Library\GD32F4xx_standard_peripheral\Include; ..\libraries\GD32F4xx_Firmware_Library\CMSIS\GD\GD32F4xx\Include; ..\rt-thread\components\net\sal\include\socket\sys_socket; ..\rt-thread\components\finsh; ..\rt-thread\components\libc\posix\io\stdio; ..\rt-thread\components\drivers\wlan; ..\rt-thread\components\net\netdev\include; ..\rt-thread\components\net\sal\include\dfs_net; ..\rt-thread\components\net\lwip\lwip-2.0.3\src\include; ..\libraries\gd32_drivers; ..\rt-thread\components\drivers\spi; ..\libraries\GD32F4xx_Firmware_Library\CMSIS; ..\rt-thread\components\dfs\filesystems\elmfat; ..\packages\rw007\inc; ..\rt-thread\components\net\lwip\lwip-2.0.3\src\include\ipv4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: project.srec
  ILINK.IlinkOutputFile: rtthread.out
  ILINK.IlinkIcfFile: board\linker_scripts\link.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; CLOCKS_PER_SEC=RT_TICK_PER_SECOND; RT_USING_DLIBC; RT_USING_LIBC; _DLIB_ADD_EXTRA_SYMBOLS=0; _DLIB_FILE_DESCRIPTOR; _DLIB_THREAD_SUPPORT; GD32F470; __RTTHREAD__; USE_STDPERIPH_DRIVER
  ICCARM.CCOptLevel: 3
  group Applications
    ../applications/: main.c
  group Compiler
    ../rt-thread/components/libc/compilers/common/: cctype.c cstdio.c cstdlib.c cstring.c ctime.c cwchar.c
    ../rt-thread/components/libc/compilers/dlib/: environ.c syscall_close.c syscall_lseek.c syscall_mem.c syscall_open.c syscall_read.c syscall_remove.c syscall_write.c syscalls.c
  group CPU
    ../rt-thread/libcpu/arm/common/: div0.c showmem.c
    ../rt-thread/libcpu/arm/cortex-m4/: context_iar.S cpuport.c
  group DeviceDrivers
    ../rt-thread/components/drivers/ipc/: completion.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../rt-thread/components/drivers/misc/: pin.c
    ../rt-thread/components/drivers/mtd/: mtd_nor.c
    ../rt-thread/components/drivers/rtc/: rtc.c
    ../rt-thread/components/drivers/serial/: serial.c
    ../rt-thread/components/drivers/spi/: spi_core.c spi_dev.c
    ../rt-thread/components/drivers/wlan/: wlan_cfg.c wlan_cmd.c wlan_dev.c wlan_lwip.c wlan_mgnt.c wlan_prot.c wlan_workqueue.c
  group Drivers
    ../board/: board.c
    ../board/ports/: rw007_port.c
    ../libraries/GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/IAR/: startup_gd32f4xx.s
    ../libraries/gd32_drivers/: drv_flash.c drv_gpio.c drv_rtc.c drv_spi.c drv_usart.c
  group Fal
    ../rt-thread/components/fal/src/: fal_rtt.c fal_flash.c fal_partition.c fal.c
  group Filesystem
    ../rt-thread/components/dfs/filesystems/devfs/: devfs.c
    ../rt-thread/components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
    ../rt-thread/components/dfs/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../rt-thread/components/finsh/: shell.c msh.c msh_parse.c cmd.c msh_file.c
  group Kernel
    ../rt-thread/src/: clock.c components.c device.c idle.c ipc.c irq.c kservice.c mem.c mempool.c object.c scheduler_up.c thread.c timer.c
  group Libraries
    ../libraries/GD32F4xx_Firmware_Library/GD32F4xx_standard_peripheral/Source/: gd32f4xx_syscfg.c gd32f4xx_exti.c gd32f4xx_gpio.c gd32f4xx_rcu.c gd32f4xx_fmc.c gd32f4xx_pmu.c gd32f4xx_misc.c gd32f4xx_usart.c gd32f4xx_spi.c gd32f4xx_rtc.c
    ../libraries/GD32F4xx_Firmware_Library/CMSIS/GD/GD32F4xx/Source/: system_gd32f4xx.c
  group lwIP
    ../rt-thread/components/net/lwip/lwip-2.0.3/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../rt-thread/components/net/lwip/lwip-2.0.3/src/apps/ping/: ping.c
    ../rt-thread/components/net/lwip/lwip-2.0.3/src/core/: def.c dns.c inet_chksum.c init.c ip.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../rt-thread/components/net/lwip/lwip-2.0.3/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../rt-thread/components/net/lwip/lwip-2.0.3/src/netif/: ethernet.c lowpan6.c
    ../rt-thread/components/net/lwip/port/: ethernetif.c sys_arch.c
  group mbedtls
    ../packages/mbedtls/mbedtls/library/: chacha20.c nist_kw.c x509_crl.c psa_its_file.c chachapoly.c mps_reader.c ssl_tls.c ecjpake.c x509_csr.c sha256.c pem.c cmac.c dhm.c ssl_cookie.c aes.c psa_crypto_aead.c psa_crypto_driver_wrappers.c entropy.c ssl_cache.c arc4.c pkcs11.c error.c oid.c pk_wrap.c constant_time.c ecp_curves.c md4.c psa_crypto_mac.c cipher_wrap.c ecdh.c ssl_tls13_keys.c psa_crypto_client.c asn1parse.c pk.c base64.c padlock.c version.c ssl_msg.c platform.c ctr_drbg.c ecdsa.c psa_crypto_hash.c gcm.c sha512.c camellia.c threading.c psa_crypto_se.c asn1write.c pkwrite.c blowfish.c memory_buffer_alloc.c timing.c ripemd160.c platform_util.c cipher.c ssl_ciphersuites.c pkcs12.c des.c version_features.c aria.c psa_crypto_cipher.c ecp.c hkdf.c poly1305.c md.c psa_crypto_slot_management.c aesni.c hmac_drbg.c x509_create.c pkparse.c md5.c x509.c rsa_internal.c havege.c md2.c rsa.c ssl_srv.c certs.c mps_trace.c psa_crypto_storage.c sha1.c psa_crypto_ecp.c x509write_crt.c ssl_cli.c psa_crypto.c bignum.c entropy_poll.c xtea.c x509write_csr.c pkcs5.c ccm.c debug.c psa_crypto_rsa.c x509_crt.c ssl_ticket.c
    ../packages/mbedtls/ports/src/: arc4_alt.c sha256_alt.c timing_alt.c tls_certificate.c sha1_alt.c des_alt.c sha512_alt.c tls_client.c md5_alt.c rsa_alt.c tls_hardware.c aes_alt.c tls_net.c
  group NetUtils
    ../packages/netutils/iperf/: iperf.c
    ../packages/netutils/netio/: netio.c
    ../packages/netutils/ntp/: ntp.c
    ../packages/netutils/tcpdump/: tcpdump.c
    ../packages/netutils/telnet/: telnet.c
    ../packages/netutils/tftp/: tftp_client.c tftp_port.c tftp_server.c tftp_xfer.c
  group optparse
    ../packages/optparse/: optparse.c
  group paho-mqtt
    ../packages/pahomqtt/MQTTPacket/src/: MQTTSubscribeClient.c MQTTConnectClient.c MQTTUnsubscribeClient.c MQTTPacket.c MQTTSubscribeServer.c MQTTConnectServer.c MQTTUnsubscribeServer.c MQTTFormat.c MQTTSerializePublish.c MQTTDeserializePublish.c
    ../packages/pahomqtt/tests/: mqtt_test.c
    ../packages/pahomqtt/samples/: mqtt_sample.c
    ../packages/pahomqtt/MQTTClient-RT/: paho_mqtt_pipe.c
  group POSIX
    ../rt-thread/components/libc/posix/io/poll/: poll.c select.c
  group rw007
    ../packages/rw007/src/: spi_wifi_rw007.c
  group SAL
    ../rt-thread/components/net/netdev/src/: netdev.c netdev_ipaddr.c
    ../rt-thread/components/net/sal/dfs_net/: dfs_net.c
    ../rt-thread/components/net/sal/impl/: af_inet_lwip.c
    ../rt-thread/components/net/sal/socket/: net_netdb.c net_sockets.c
    ../rt-thread/components/net/sal/src/: sal_socket.c
  group Utilities
    ../rt-thread/components/utilities/resource/: resource_id.c
  group WebClient
    ../packages/webclient/src/: webclient.c webclient_file.c
